/* ============================================================================
 *  font_ascii.h — FONT 5×7 (chữ HOA + số + dấu) cho lớp vẽ raw-framebuffer P4
 *  ----------------------------------------------------------------------------
 *  Bản CYD dùng font dựng sẵn của TFT_eSPI. Bo P4 vẽ thẳng framebuffer nên phải
 *  tự có font. Đây là font 5×7 cổ điển (giống "font 1" của TFT_eSPI): chữ HOA
 *  A–Z, số 0–9, và các dấu cần cho giao diện. Chữ thường tự quy về chữ HOA.
 *  Dấu tiếng Việt: máy chủ đã BỎ DẤU trước khi gửi (xem ghi chú bản CYD) nên chỉ
 *  cần ASCII. Glyph vẽ qua bộ khử răng cưa lBitmap() (hàng-trước, 5 bit/hàng).
 * ========================================================================== */
#pragma once
#include <stdint.h>

static const uint8_t FONT_DIGIT[10][7] = {
  {0x0E,0x11,0x13,0x15,0x19,0x11,0x0E},{0x04,0x0C,0x04,0x04,0x04,0x04,0x0E},
  {0x0E,0x11,0x01,0x02,0x04,0x08,0x1F},{0x1F,0x02,0x04,0x02,0x01,0x11,0x0E},
  {0x02,0x06,0x0A,0x12,0x1F,0x02,0x02},{0x1F,0x10,0x1E,0x01,0x01,0x11,0x0E},
  {0x06,0x08,0x10,0x1E,0x11,0x11,0x0E},{0x1F,0x01,0x02,0x04,0x08,0x08,0x08},
  {0x0E,0x11,0x11,0x0E,0x11,0x11,0x0E},{0x0E,0x11,0x11,0x0F,0x01,0x02,0x0C},
};
static const uint8_t FONT_UPPER[26][7] = {
  {0x0E,0x11,0x11,0x1F,0x11,0x11,0x11}, // A
  {0x1E,0x11,0x11,0x1E,0x11,0x11,0x1E}, // B
  {0x0E,0x11,0x10,0x10,0x10,0x11,0x0E}, // C
  {0x1E,0x11,0x11,0x11,0x11,0x11,0x1E}, // D
  {0x1F,0x10,0x10,0x1E,0x10,0x10,0x1F}, // E
  {0x1F,0x10,0x10,0x1E,0x10,0x10,0x10}, // F
  {0x0E,0x11,0x10,0x17,0x11,0x11,0x0F}, // G
  {0x11,0x11,0x11,0x1F,0x11,0x11,0x11}, // H
  {0x0E,0x04,0x04,0x04,0x04,0x04,0x0E}, // I
  {0x07,0x02,0x02,0x02,0x02,0x12,0x0C}, // J
  {0x11,0x12,0x14,0x18,0x14,0x12,0x11}, // K
  {0x10,0x10,0x10,0x10,0x10,0x10,0x1F}, // L
  {0x11,0x1B,0x15,0x15,0x11,0x11,0x11}, // M
  {0x11,0x19,0x19,0x15,0x13,0x13,0x11}, // N
  {0x0E,0x11,0x11,0x11,0x11,0x11,0x0E}, // O
  {0x1E,0x11,0x11,0x1E,0x10,0x10,0x10}, // P
  {0x0E,0x11,0x11,0x11,0x15,0x12,0x0D}, // Q
  {0x1E,0x11,0x11,0x1E,0x14,0x12,0x11}, // R
  {0x0F,0x10,0x10,0x0E,0x01,0x01,0x1E}, // S
  {0x1F,0x04,0x04,0x04,0x04,0x04,0x04}, // T
  {0x11,0x11,0x11,0x11,0x11,0x11,0x0E}, // U
  {0x11,0x11,0x11,0x11,0x11,0x0A,0x04}, // V
  {0x11,0x11,0x11,0x15,0x15,0x1B,0x11}, // W
  {0x11,0x11,0x0A,0x04,0x0A,0x11,0x11}, // X
  {0x11,0x11,0x0A,0x04,0x04,0x04,0x04}, // Y
  {0x1F,0x01,0x02,0x04,0x08,0x10,0x1F}, // Z
};
static const uint8_t GLYPH_DD[7]   = {0x03,0x0F,0x0F,0x11,0x11,0x11,0x0F}; // đ
static const uint8_t _G_SPACE[7]   = {0,0,0,0,0,0,0};
static const uint8_t _G_DOT[7]     = {0,0,0,0,0,0x06,0x06};
static const uint8_t _G_COMMA[7]   = {0,0,0,0,0,0x06,0x08};
static const uint8_t _G_COLON[7]   = {0,0x06,0x06,0,0x06,0x06,0};
static const uint8_t _G_MINUS[7]   = {0,0,0,0x0E,0,0,0};
static const uint8_t _G_GT[7]      = {0x08,0x04,0x02,0x01,0x02,0x04,0x08};
static const uint8_t _G_LT[7]      = {0x02,0x04,0x08,0x10,0x08,0x04,0x02};
static const uint8_t _G_PCT[7]     = {0x19,0x19,0x02,0x04,0x08,0x13,0x13};
static const uint8_t _G_LP[7]      = {0x02,0x04,0x08,0x08,0x08,0x04,0x02};
static const uint8_t _G_RP[7]      = {0x08,0x04,0x02,0x02,0x02,0x04,0x08};
static const uint8_t _G_AMP[7]     = {0x0C,0x12,0x14,0x08,0x15,0x12,0x0D};
static const uint8_t _G_SLASH[7]   = {0x01,0x02,0x02,0x04,0x08,0x08,0x10};
static const uint8_t _G_EXCL[7]    = {0x04,0x04,0x04,0x04,0x04,0,0x04};
static const uint8_t _G_QUES[7]    = {0x0E,0x11,0x01,0x02,0x04,0,0x04};
static const uint8_t _G_PLUS[7]    = {0,0x04,0x04,0x1F,0x04,0x04,0};
static const uint8_t _G_APOS[7]    = {0x04,0x04,0x08,0,0,0,0};
static const uint8_t _G_STAR[7]    = {0,0x15,0x0E,0x1F,0x0E,0x15,0};

static inline const uint8_t* glyph7(char c) {
  if (c >= '0' && c <= '9') return FONT_DIGIT[c - '0'];
  if (c >= 'A' && c <= 'Z') return FONT_UPPER[c - 'A'];
  if (c >= 'a' && c <= 'z') return FONT_UPPER[c - 'a'];
  switch (c) {
    case '.': return _G_DOT;   case ',': return _G_COMMA; case ':': return _G_COLON;
    case '-': return _G_MINUS; case '>': return _G_GT;    case '<': return _G_LT;
    case '%': return _G_PCT;   case '(': return _G_LP;    case ')': return _G_RP;
    case '&': return _G_AMP;   case '/': return _G_SLASH; case '!': return _G_EXCL;
    case '?': return _G_QUES;  case '+': return _G_PLUS;  case '\'': return _G_APOS;
    case '*': return _G_STAR;
    default:  return _G_SPACE;
  }
}
